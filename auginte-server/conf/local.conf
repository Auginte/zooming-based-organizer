## auginte-server/conf/local.conf
```bitbake
# Will be replaced in production envifonment

orientdb.password="kramtauauginte"
```
